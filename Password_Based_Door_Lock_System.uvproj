# Keil uVision project Password_Based_Door_Lock_System.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Password_Final +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: password_final.asm
